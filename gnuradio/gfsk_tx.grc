<?xml version='1.0' encoding='utf-8'?>
<?grc format='1' created='3.7.10'?>
<flow_graph>
<block>
<key>options</key>
<param><key>id</key><value>gfsk_tx</value></param>
<param><key>author</key><value>"Gabriel Mariano Marcelino"</value></param>
<param><key>category</key><value>Custom</value></param>
<param><key>generate_options</key><value>no_gui</value></param>
<param><key>realtime_scheduling</key><value>1</value></param>
<param><key>run_options</key><value>run</value></param>
<param><key>title</key><value>GFSK TX</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>bps</value></param>
<param><key>value</key><value>1</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>deviation</value></param>
<param><key>value</key><value>3200</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>mod_index</value></param>
<param><key>value</key><value>deviation/baudrate/0.628</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>samp_rate</value></param>
<param><key>value</key><value>sps*baudrate</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>sps</value></param>
<param><key>value</key><value>10</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>baudrate</value></param>
<param><key>label</key><value>baudrate</value></param>
<param><key>short_id</key><value>b</value></param>
<param><key>type</key><value>intx</value></param>
<param><key>value</key><value>9600</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>bin_file_input</value></param>
<param><key>label</key><value>input_file</value></param>
<param><key>short_id</key><value>o</value></param>
<param><key>type</key><value>string</value></param>
<param><key>value</key><value>/tmp/tx_data.bin</value></param>
</block>
<block>
<key>blocks_file_source</key>
<param><key>id</key><value>blocks_file_source_0</value></param>
<param><key>file</key><value>/tmp/tx_data.bin</value></param>
<param><key>type</key><value>byte</value></param>
<param><key>repeat</key><value>False</value></param>
</block>
<block>
<key>digital_gfsk_mod</key>
<param><key>id</key><value>digital_gfsk_mod_0</value></param>
<param><key>bt</key><value>0.5</value></param>
<param><key>samples_per_symbol</key><value>sps</value></param>
<param><key>sensitivity</key><value>(3.14*mod_index)/sps</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>freq</value></param>
<param><key>label</key><value>frequency</value></param>
<param><key>short_id</key><value>f</value></param>
<param><key>type</key><value>eng_float</value></param>
<param><key>value</key><value>437.5e6</value></param>
</block>
<block>
<key>osmosdr_sink</key>
<param><key>id</key><value>osmosdr_sink_0</value></param>
<param><key>bb_gain0</key><value>20</value></param>
<param><key>freq0</key><value>freq</value></param>
<param><key>if_gain0</key><value>20</value></param>
<param><key>gain0</key><value>30</value></param>
<param><key>args</key><value>sdr_dev</value></param>
<param><key>type</key><value>fc32</value></param>
<param><key>sample_rate</key><value>samp_rate_tx</value></param>
<param><key>sync</key><value></value></param>
</block>
<block>
<key>qtgui_freq_sink_x</key>
<param><key>id</key><value>qtgui_freq_sink_x_0</value></param>
<param><key>bw</key><value>samp_rate</value></param>
<param><key>fc</key><value>freq</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>fftsize</key><value>2048</value></param>
<param><key>name</key><value>"TX"</value></param>
<param><key>showports</key><value>True</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>wintype</key><value>firdes.WIN_BLACKMAN_hARRIS</value></param>
</block>
<block>
<key>rational_resampler_xxx</key>
<param><key>id</key><value>rational_resampler_xxx_0</value></param>
<param><key>decim</key><value>samp_rate</value></param>
<param><key>interp</key><value>samp_rate_tx</value></param>
<param><key>taps</key><value></value></param>
<param><key>type</key><value>ccc</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>samp_rate_tx</value></param>
<param><key>label</key><value>samp_rate</value></param>
<param><key>short_id</key><value>s</value></param>
<param><key>type</key><value>intx</value></param>
<param><key>value</key><value>4000000</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>sdr_dev</value></param>
<param><key>label</key><value>sdr_dev</value></param>
<param><key>short_id</key><value>d</value></param>
<param><key>type</key><value>string</value></param>
<param><key>value</key><value>rtl=0</value></param>
</block>
<connection><source_block_id>blocks_file_source_0</source_block_id><sink_block_id>digital_gfsk_mod_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>digital_gfsk_mod_0</source_block_id><sink_block_id>rational_resampler_xxx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>rational_resampler_xxx_0</source_block_id><sink_block_id>osmosdr_sink_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>rational_resampler_xxx_0</source_block_id><sink_block_id>qtgui_freq_sink_x_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
</flow_graph>
